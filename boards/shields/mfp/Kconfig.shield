## boards/shields/mfp/Kconfig.shield
```kconfig
# Copyright (c) 2020 Ryan Cross
# SPDX-License-Identifier: MIT

config SHIELD_MFP
    def_bool $(shields_list_contains,mfp)
```
